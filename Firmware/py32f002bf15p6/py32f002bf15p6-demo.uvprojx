# Keil uVision project py32f002bf15p6-demo.uvprojx, settings and files
target Target (6220000::V6.22::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: py32f002bf15p6-demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32F002Bx5 RCC_HSI48M_SUPPORT
  c include: .\Libraries\PY32F002B_LL_Driver\Inc;.\Libraries\PY32F002B_LL_BSP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group User
    ./User/: main.c py32f002b_it.c
    ./Libraries/PY32F002B_LL_Driver/Src/: py32f002b_ll_utils.c
    ./Libraries/PY32F002B_LL_BSP/Src/: py32f002b_bsp_clock.c py32f002b_bsp_printf.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 1.0.0
